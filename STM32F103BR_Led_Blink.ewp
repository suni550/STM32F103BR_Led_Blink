# IAR project STM32F103BR_Led_Blink.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RB ST STM32F103RB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: Imt.Base; STM_HAL; src; App
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: STM32F103BR_Led_Blink.srec
  ILINK.IlinkOutputFile: STM32F103BR_Led_Blink.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group App
    App/: LedBlink.cpp LedBlink.h
  group src
    src/: ApplicationHardwareConfig.cpp ApplicationHardwareConfig.h LinkerConfig.icf main.cpp SystemInitializationDriver.cpp SystemInitializationDriver.h types.h
  group STM_HAL
    STM_HAL/: Core_CortexM3.h SystemMemoryMap.h SystemPeripherals_EXTI.c SystemPeripherals_EXTI.h SystemPeripherals_GPIO.c SystemPeripherals_GPIO.h SystemPeripherals_NVIC.c SystemPeripherals_NVIC.h SystemPeripherals_RCC.c SystemPeripherals_RCC.h SystemStartup.s vector_table_M.s
