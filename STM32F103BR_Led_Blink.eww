<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\STM32F103BR_Led_Blink.ewp</path>
    </project>
    <batchBuild />
</workspace>
